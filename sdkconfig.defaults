## sdkconfig.defaults
```kconfig
CONFIG_ESP_COREDUMP_ENABLE=n
CONFIG_ESP_COREDUMP_DATA_FORMAT_ELF=n
CONFIG_ESP_COREDUMP_LOGS=n
```
